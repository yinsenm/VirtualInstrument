# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: slave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1602.c delay.c i2c.c main.c modbus.c tm7705.c uart.c 1602.h delay.h i2c.h modbus.h tm7705.h uart.h speaker.h
